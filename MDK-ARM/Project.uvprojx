# Keil uVision project Project.uvprojx, settings and files
target multiwii_2.4_STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: multiwill_2.4_STM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\CMSIS\CM3\CoreSupport;..\multiwii_2.4;..\Public;..\USB\lib;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\BSP;..\USB;..\LL_Drievers\STM32\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group multiwii
    ../multiwii_2.4/: Alarms.c EEPROM.c GPS.c IMU.c Protocol.c MultiWii.c Output.c Sensors.c Serial.c RX.c config.h
  group User
    ../USER/: re_eeprom.c SPL06_001.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Doc
    ../: README.MD
  group USB
    ../USB/: USB_CH341.c STM32F10xR.LIB
  group LL_Driver
    ../LL_Drievers/STM32/src/: stm32f10x_it.c timer.c system_stm32f10x.c delay.c gy_86.c usart2.c sys.c
  group LL_Driver_GD32
    ../LL_Drievers/GD32/src/: i2c.c leds.c spi.c sys.c timer.c uart.c
    ../Libraries/CMSIS/GD32F3x0/Source/: system_gd32f3x0.c
  group STD_LIB_GD32
    ../Libraries/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
target multiwill_2.4_GD32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F330C8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: multiwill_2.4_GD32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\multiwii_2.4;..\Public;..\USB\lib;..\USER;..\BSP;..\USB;..\Libraries\CMSIS\GD32F3x0\Include;..\LL_Drievers\GD32\inc;..\Libraries\CMSIS;..\Libraries\GD32F3x0_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
